options:
  parameters:
    author: guji
    generate_options: qt_gui
    id: AM_detect
    output_language: python
    title: AM_detect
  states: {}

blocks:
- name: digital_IF_freq
  id: variable
  parameters:
    comment: |-
      Tested: 
      2.5MHz for N210 and N310; 
      0MHz for X410.
    value: 2.5e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      12.5MHz for N210 and N310
      6.25MHz for X410
    value: 12.5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.81'
    freq: 2.5e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: digital_IF_freq+2e6
    low_cutoff_freq: digital_IF_freq-2e6
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: 1e6
    win: window.WIN_BLACKMAN
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wtnt-slu-ue1/guji/Channel_Sounding/long_tern_AM/N210_RX_record.fc32.bin
    repeat: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(2*samp_rate/125)
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_DOUBLE
    file: /home/wtnt-slu-ue1/guji/Channel_Sounding/long_tern_AM/FUCK_N210.wav
    format: FORMAT_WAV
    samp_rate: int(samp_rate/125)
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 40e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 10e3
    win: window.WIN_BLACKMAN
  states: {state: bypassed}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/125
    fc: '0'
    fftsize: '32768'
    type: float
  states: {}
- name: qtgui_sink_x_5
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '65536'
    srate: samp_rate/125
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '32768'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '25'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    type: fff
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: 2100e6
    dev_addr: '"addr=192.168.10.2"'
    gain0: '25.5'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: 2100e6
    dev_addr: '"addr=192.168.10.3"'
    gain0: '10'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:1145
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [band_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [band_pass_filter_0, '0', qtgui_sink_x_5, '0']
- [blocks_complex_to_mag_0, '0', low_pass_filter_1, '0']
- [blocks_file_source_0, '0', band_pass_filter_0, '0']
- [blocks_skiphead_0, '0', blocks_wavfile_sink_0, '0']
- [low_pass_filter_1, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', blocks_skiphead_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [rational_resampler_xxx_0_0, '0', rational_resampler_xxx_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', rational_resampler_xxx_0, '0']
- [uhd_usrp_source_0, '0', band_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_1, '0']
- [zeromq_sub_source_0, '0', band_pass_filter_0, '0']
- [zeromq_sub_source_0, '0', qtgui_time_sink_x_1, '0']

metadata:
  file_format: 1
