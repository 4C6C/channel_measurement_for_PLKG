options:
  parameters:
    author: 4C6C
    generate_options: qt_gui
    id: temp
    output_language: python
    title: temp
  states: {}

blocks:
- name: RSSI_high_cutoff_freq
  id: variable
  parameters:
    value: '14'
  states: {}
- name: RSSI_low_cutoff_freq
  id: variable
  parameters:
    value: '1.2'
  states: {}
- name: csi1_bias
  id: variable_qtgui_range
  parameters:
    label: csi1_bias
    start: '-100'
    step: '0.1'
    stop: '100'
    value: '0'
  states: {}
- name: csi1_scaling
  id: variable_qtgui_range
  parameters:
    label: csi1_scaling
    start: '0.7'
    step: '0.01'
    stop: '1.1'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1/(200e-6)
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: RSSI_high_cutoff_freq
    low_cutoff_freq: RSSI_low_cutoff_freq
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: RSSI_high_cutoff_freq
    low_cutoff_freq: RSSI_low_cutoff_freq
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: csi1_bias
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    num_ports: '2'
    type: float
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/20)
    type: float
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: int(samp_rate/20)
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '10000'
    max_iter: '4000'
    scale: 1/10000
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: csi1_scaling
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_nlog10_ff_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_1
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_sub_xx_1_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_FLOAT
    file: /home/wtnt-slu-ue1/guji/Channel_Sounding_202601/TDD_channel_measuring/data/2170MHz_905_dynamic_3mdist_LoS_N210_5ksps_202601_f32.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(samp_rate)
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/wtnt-slu-ue1/guji/Channel_Modeling/usrp_n310_rx_T2000us_no_tx_set_to_zero-5samples.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: int(12.5e6)
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: dc_blocker_xx_0_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import socket
      import select
      from gnuradio import gr
      import struct
      import zlib
      import time


      # from time import sleep

      class csi_rpt:
          def __init__(self, timestamp, data):
              self.timestamp = timestamp
              self.data = data

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, ueA_addr = "127.0.0.1", ueB_addr = "127.0.0.1", remote_A_port = 19198, remote_B_port = 19199):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='TDD CSI Reader',   # will show up in GRC
                  in_sig=[],
                  out_sig=[np.float32, np.float32]
              )
              self.sock_connected = False
              self.ueA_addr = ueA_addr
              self.ueB_addr = ueB_addr
              self.remoteA_port = remote_A_port
              self.remoteB_port = remote_B_port
              self.ueA_pkts_queue:list[csi_rpt] = []
              self.ueB_pkts_queue:list[csi_rpt] = []
              

          def work(self, input_items, output_items):
              # print("!!!! ", self.p_txbuf, np.size(self.txbuf))
              if(not self.sock_connected):
                  self.udpsock = socket.socket(socket.AF_INET, socket.SOCK_DGRAM)
                  self.udpsock.bind(("0.0.0.0", 1146)) # Local port
                  # self.udpsock.setblocking(False)
                  time.sleep(0.5)
                  self.udpsock.sendto(b"Start!", (self.ueA_addr, self.remoteA_port))
                  self.udpsock.sendto(b"Start!", (self.ueB_addr, self.remoteB_port))
                  self.sock_connected = True
                  # while True:
                  #     readible, writable, exeptional = select.select([self.udpsock], [], [], 0)
                  #     if(not readible):
                  #         break
                  #     print("!!!!!!!!!!!!!!!!")
                  #     print(self.udpsock.recv(1500))

              if(np.size(output_items[0]) < 200):
                  return 0
              
              while(True):
                  if(len(self.ueA_pkts_queue) and len(self.ueB_pkts_queue)):
                      if(self.ueA_pkts_queue[0].timestamp == self.ueB_pkts_queue[0].timestamp):
                          break
                      elif(self.ueA_pkts_queue[0].timestamp < self.ueB_pkts_queue[0].timestamp):
                          for i in range(len(self.ueA_pkts_queue)):
                              if(self.ueA_pkts_queue[i].timestamp >= self.ueB_pkts_queue[0].timestamp):
                                  i -= 1
                                  break
                          self.ueA_pkts_queue = self.ueA_pkts_queue[i+1:]
                      else:
                          for i in range(len(self.ueB_pkts_queue)):
                              if(self.ueB_pkts_queue[i].timestamp >= self.ueA_pkts_queue[0].timestamp):
                                  i -= 1
                                  break
                          self.ueB_pkts_queue = self.ueB_pkts_queue[i+1:]
                  else:
                      # UDP RX
                      msg = self.udpsock.recv(1500)
                      # print(msg[0:1].decode('utf-8'), int.from_bytes(msg[1:9]))
                      # csis_received = np.frombuffer(msg[9:], dtype=np.float32)
                      if(msg[0:1] == b'A'):
                          if(len(self.ueA_pkts_queue)>10):
                              self.ueA_pkts_queue.pop(0)
                          self.ueA_pkts_queue.append(csi_rpt(int.from_bytes(msg[1:9], 'big', signed=False), msg[9:]))
                      elif(msg[0:1] == b'B'):
                          if(len(self.ueB_pkts_queue)>10):
                              self.ueB_pkts_queue.pop(0)
                          self.ueB_pkts_queue.append(csi_rpt(int.from_bytes(msg[1:9], 'big', signed=False), msg[9:]))
                      else:
                          pass
              # CSI out
              # print("CSI #", self.ueA_pkts_queue[0].timestamp)
              ndata = len(self.ueA_pkts_queue[0].data)>>2
              output_items[0][:ndata] = np.frombuffer(self.ueA_pkts_queue[0].data, dtype=np.float32)
              output_items[1][:ndata] = np.frombuffer(self.ueB_pkts_queue[0].data, dtype=np.float32)
              self.ueA_pkts_queue.pop(0)
              self.ueB_pkts_queue.pop(0)
              return ndata
              # while(True):
              #     readible, writable, exeptional = select.select([self.udpsock], [], [], 0)
              #     if(len(readible)):
              #         msg = self.udpsock.recv(1500)
              #         break
              # print(len(msg))
              # msg = self.udpsock.recv(1500)
              # pkt_received = np.frombuffer(msg, dtype=np.float32)
              # print(msg)
              # return 100
              # print(np.size(pkt_received))
              # output_items[0][:np.size(pkt_received)] = pkt_received[:]
              # return np.size(pkt_received)
    remote_A_port: '19198'
    remote_B_port: '19199'
    ueA_addr: '''127.0.0.1'''
    ueB_addr: '''127.0.0.1'''
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '2'
    decim: '1'
    gain: '1'
    samp_rate: 2e3
    type: fir_filter_fff
    width: '1'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: high_pass_filter_0_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '2'
    decim: '1'
    gain: '1'
    samp_rate: 2e3
    type: fir_filter_fff
    width: '1'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_sink_x_5
  id: qtgui_sink_x
  parameters:
    bw: 12.5e6
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_sink_x_5_0
  id: qtgui_sink_x
  parameters:
    bw: 12.5e6
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '10000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '10000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"HPF"'
    nconnections: '2'
    size: '10000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"HPF"'
    nconnections: '2'
    size: int(10000/samp_rate*20)
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: '"HPF"'
    nconnections: '2'
    size: '10000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '20480'
    srate: 12.5e6
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '138'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    name: '"CV"'
    nconnections: '3'
    size: '128'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:1145
    timeout: '100'
    type: complex
  states: {state: disabled}

connections:
- [band_pass_filter_0, '0', dc_blocker_xx_0, '0']
- [band_pass_filter_0_0, '0', dc_blocker_xx_0_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_nlog10_ff_1_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_wavfile_sink_0, '1']
- [blocks_add_const_vxx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_2, '1']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_1, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_1, '1']
- [blocks_complex_to_mag_0, '0', qtgui_sink_x_5_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_delay_0, '0', blocks_sub_xx_1, '1']
- [blocks_delay_0, '1', blocks_sub_xx_1_0, '1']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', qtgui_time_sink_x_0_0_0_0, '1']
- [blocks_moving_average_xx_0, '0', blocks_sub_xx_0, '1']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_float_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_sink_x_5, '0']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_2_0, '2']
- [blocks_nlog10_ff_1, '0', band_pass_filter_0, '0']
- [blocks_nlog10_ff_1, '0', high_pass_filter_0, '0']
- [blocks_nlog10_ff_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_nlog10_ff_1_0, '0', band_pass_filter_0_0, '0']
- [blocks_nlog10_ff_1_0, '0', high_pass_filter_0_0, '0']
- [blocks_nlog10_ff_1_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '0']
- [blocks_sub_xx_0, '0', blocks_multiply_xx_0, '1']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_2_0, '1']
- [blocks_sub_xx_1, '0', blocks_keep_one_in_n_0, '0']
- [blocks_sub_xx_1, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [blocks_sub_xx_1_0, '0', blocks_keep_one_in_n_0_0, '0']
- [blocks_sub_xx_1_0, '0', qtgui_time_sink_x_0_0_0_1, '1']
- [dc_blocker_xx_0, '0', blocks_delay_0, '0']
- [dc_blocker_xx_0, '0', blocks_sub_xx_1, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [dc_blocker_xx_0_0, '0', blocks_delay_0, '1']
- [dc_blocker_xx_0_0, '0', blocks_sub_xx_1_0, '0']
- [dc_blocker_xx_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [epy_block_0, '0', blocks_moving_average_xx_0, '0']
- [epy_block_0, '0', blocks_nlog10_ff_1, '0']
- [epy_block_0, '0', blocks_sub_xx_0, '0']
- [epy_block_0, '0', blocks_wavfile_sink_0, '0']
- [epy_block_0, '0', qtgui_freq_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_2, '0']
- [epy_block_0, '1', blocks_multiply_const_vxx_0, '0']
- [zeromq_sub_source_0, '0', blocks_multiply_const_vxx_1, '0']

metadata:
  file_format: 1
